# Keil uVision project nxp_lpc845_rom.uvprojx, settings and files
target nxp_lpc845_rom (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC845M301JBD64 NXP
  pack: NXP.LPC845_DFP.12.2.0
  cpu: IRAM(0x10003fe0,0x20) IRAM2(0x10000000,0x3fe0) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: nxp_lpc845_rom +hex
  AfterMake: fromelf --bincombined --bincombined_base=0x00008000 -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_LPC845M301JBD64
  c misc: --diag_suppress 1296
  c include: ..\source\chip;..\source\config;..\source\main;..\source\method;..\reference\mcu_framework;..\reference\mcu_framework_lpc845;..\reference\nxp_lpc845_driver;..\debug
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10003fe0 size 0x20
  memory RVCT10: RAM 0x10000000 size 0x3fe0
  scatter file: .\nxp_lpc845_rom_flash.scf
  group chip
    ../source/chip/: startup_LPC845.s system_LPC845.c system_LPC845.h
  group main
    ../source/main/: loop.c main.c start.c
  group method
    ../source/method/: periph_io.c terminal.c bootloader.c timer.c
  group command
    ../source/command/: command_info.c command_led.c command_reboot.c
  group config
    ../source/config/: fw_define.h
  group mcu_framework
    ../reference/mcu_framework/: fw_io.h fw_io_entity.h fw_spi.h fw_spi_entity.h fw_usart.h fw_usart_entity.h
  group mcu_framework_lpc845
    ../reference/mcu_framework_lpc845/: Framework-LPC845.lib fw_chip.h fw_chip_type.h fw_define.c fw_define_type.h fw_io_type.h fw_spi_type.h fw_usart_type.h
  group nxp_lpc845_driver
    ../reference/nxp_lpc845_driver/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm0plus.h Framework-LPC845.lib fsl_acomp.h fsl_adc.h fsl_capt.h fsl_clock.h fsl_common.h fsl_crc.h fsl_ctimer.h fsl_dac.h fsl_device_registers.h fsl_dma.h fsl_gpio.h fsl_i2c.h fsl_iap.h fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_mrt.h fsl_pint.h fsl_power.h fsl_reset.h fsl_sctimer.h fsl_spi.h fsl_swm.h fsl_swm_connections.h fsl_syscon.h fsl_syscon_connections.h fsl_usart.h fsl_wkt.h fsl_wwdt.h LPC845.h LPC845_features.h
  group debug
    ../debug/: terminal.c terminal.h terminal_entity.h
